## sample.yaml
```yaml
sample:
  name: DS18B20 Temperature Sensor sample
common:
  harness: console
  tags: sensors
```
